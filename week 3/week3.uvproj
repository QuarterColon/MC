# Keil uVision project week3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ED2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: week3
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: w3q3.asm w3q2.asm w3q4.asm
