# Keil uVision project 1.arm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ED2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: 1.arm
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: W2Q4.a51 W2Q2.a51 W2Q3.a51 nbgs.a51
